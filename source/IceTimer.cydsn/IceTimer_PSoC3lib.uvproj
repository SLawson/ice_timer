# Keil uVision project IceTimer_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: IceTimer_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h LCD.c LCD.h LCD_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h startTimer_ISR.c startTimer_ISR.h stopTimer_ISR.c stopTimer_ISR.h downPosition_PIN.c downPosition_PIN.h downPosition_PIN_aliases.h upPosition_PIN.c upPosition_PIN.h upPosition_PIN_aliases.h readyTimer_ISR.c readyTimer_ISR.h Timer.c Timer.h Timer_PM.c dbnc_CLK.c dbnc_CLK.h timer_CLK.c timer_CLK.h sec_CNTR.c sec_CNTR.h sec_CNTR_PM.c min_CNTR.c min_CNTR.h min_CNTR_PM.c tenthSec_CNTR.c tenthSec_CNTR.h tenthSec_CNTR_PM.c hr_CNTR.c hr_CNTR.h hr_CNTR_PM.c
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: IceTimer_PSoC3lib (library)
  c flags: Optimize=8
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
